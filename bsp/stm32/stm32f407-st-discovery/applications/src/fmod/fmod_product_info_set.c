/*
 * @ : ***************************************************************************************
 * @Description: product
 * @version: 
 * @Author: liwei
 * @Date: 2019-10-31 11:49:01
 * @LastEditTime: 2019-10-31 11:54:25
 * @  : ***************************************************************************************
 */
/********************************************************************************************
头文件
********************************************************************************************/
#include "../../inc/fmod/fmod_product_info_set.h"
/********************************************************************************************
宏定义
********************************************************************************************/
/********************************************************************************************
变量定义
********************************************************************************************/
/********************************************************************************************
函数申明
********************************************************************************************/

/********************************************************************************************
** 函数名称：     
** 函数描述：全局变量初始化,在main函数开始时进行
** 输入参数：无
** 返回值  ：    无
********************************************************************************************/

void fmod_variable_init(void)
{				
    char timestr[20] =    "2019-01-01 00:00:00";
   	char project_name[] = "wuhu 1 line";	
	char product_name[] = "APU";
    char soft_version[] = "1.0";
    uint16_t i = 0;
	
	strcpy(st_2g_send_data.i8_timestring, timestr);  //设定初始上传时间
	
	strcpy(st_product_info.i8_project_name, project_name);  
	strcpy(st_product_info.i8_product_name, product_name);	
	strcpy(st_product_info.i8_soft_version, soft_version);
	
	st_product_info.u16_product_num = 0x0001;
	st_product_info.u16_car_num = 0x01;             //产品车号
}

/*********************************************************************************************************
** 函数名称：车号设定ABCD车，车号的组合是A-C, D-B 
** 函数描述：
** 输入参数：
** 返回值  ：无
*********************************************************************************************************///
void carid_set(void)
{
	
	if(CARID_A_FEED_VALUE == 1)  
	{
		st_product_info.u16_car_num = CAR_A;
	}
	
	if(CARID_B_FEED_VALUE == 1) 
	{
		st_product_info.u16_car_num = CAR_B;
	}
	
	if(CARID_C_FEED_VALUE == 1)  
	{
		st_product_info.u16_car_num = CAR_C;
	}

	if(CARID_D_FEED_VALUE == 1)  
	{
		st_product_info.u16_car_num = CAR_D;
	}
}
